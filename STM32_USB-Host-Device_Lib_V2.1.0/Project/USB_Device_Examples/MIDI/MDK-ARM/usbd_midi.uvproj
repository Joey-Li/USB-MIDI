# Keil uVision project usbd_midi.uvproj, settings and files
target STM322xG-EVAL_USBD-FS (ARM-ADS)
  device: STM32F217VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL_FS +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c include: ..\;..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\bsp;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\midi\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ../src/: app.c stm32fxxx_it.c usb_bsp.c usbd_usr.c usbd_desc.c
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
  group USB Driver
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group USB Device
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
    ../../../../Libraries/STM32_USB_Device_Library/Class/midi/src/: usbd_midi_core.c
  group STM32F2xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_sdio.c stm32f2xx_usart.c
  group STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval.c stm322xg_eval_ioe.c
  group Doc
    ../: readme.txt
  group inc_app
    ../inc/: usbd_conf.h usbd_desc.h stm32f2xx_conf.h stm32fxxx_it.h usb_conf.h
  group inc_usb_device
    ../../../../Libraries/STM32_USB_Device_Library/Class/midi/inc/: usbd_midi_core.h
  group bsp
    ../bsp/: serial_debug.c serial_debug.h
